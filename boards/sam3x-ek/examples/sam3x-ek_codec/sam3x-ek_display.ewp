# IAR project sam3x-ek_display.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ARM_SAM3X8__; CPU_FREQ=(84000000UL); ARCH=(ARCH_DEFAULT); WIZ_AUTOGEN; _DEBUG
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\bertos; ..\..\..\..\bertos\cpu\cortex-m3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sam3x-ek_display.srec
  ILINK.IlinkOutputFile: display.out
  ILINK.IlinkIcfFile: Z:\IAR\bertos_sam3x_trunk\bertos\cpu\cortex-m3\scripts\sam3x8_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: sam3x-ek_display.out
  group (top)
    ./: bitmaps.c logo.c logo.h main.c
    ../../../../bertos/fonts/: gohu.c
  group bertos/cfg
    ../../../../bertos/cfg/: compiler.h macros.h module.h
  group bertos/cpu/cortex-m3
    ../../../../bertos/cpu/cortex-m3/drv/: adc_sam3.c
  group bertos/cpu/cortex-m3/drv
    ../../../../bertos/cpu/cortex-m3/drv/: adc_cm3.h clock_cm3.h clock_sam3.c clock_sam3.h eth_sam3.c eth_sam3.h flash_cm3.h i2c_cm3.h irq_cm3.h kdebug_cm3.c kdebug_sam3.c ser_cm3.h ser_sam3.c ser_sam3.h timer_cm3.c timer_cm3.h
    ../../../../bertos/cpu/CORTEX-M3/drv/: irq_cm3.c
  group bertos/cpu/cortex-m3/hw
    ../../../../bertos/cpu/CORTEX-M3/hw/: crt_cm3_iar.S iar_cm3.S init_cm3.c switch_ctx_cm3.c switch_ctx_cm3.h vectors_cm3_iar.S
  group bertos/cpu/cortex-m3/io
    ../../../../bertos/cpu/cortex-m3/io/: cm3.h sam3.h sam3_adc.h sam3_emac.h sam3_flash.h sam3_ints.h sam3_nvic.h sam3_pio.h sam3_pmc.h sam3_rstc.h sam3_sdramc.h sam3_smc.h sam3_spi.h sam3_sysctl.h sam3_uart.h sam3_usart.h sam3_wdt.h sam3x.h
  group bertos/drv
    ../../../../bertos/drv/: adc.c adc.h kbd.c kbd.h kdebug.c lcd_hx8347.c lcd_hx8347.h timer.c timer.h
  group bertos/fonts
    ../../../../bertos/fonts/: luBS14.bdf luBS14.c
  group bertos/gfx
    ../../../../bertos/gfx/: bitmap.c line.c text.c text.h text_format.c
  group bertos/gui
    ../../../../bertos/gui/: menu.c menu.h
  group bertos/kern
    ../../../../bertos/kern/: coop.c irq.c irq.h kfile.h monitor.c monitor.h msg.h preempt.c proc.c proc.h proc_p.h sem.c sem.h signal.c signal.h
  group bertos/mware
    ../../../../bertos/mware/: event.c event.h formatwr.c formatwr.h hex.c hex.h sprintf.c
  group bertos/struct
    ../../../../bertos/struct/: heap.c heap.h
