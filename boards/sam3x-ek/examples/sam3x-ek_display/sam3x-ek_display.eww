<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sam3x-ek_display.ewp</path>
  </project>
  <batchBuild/>
</workspace>


